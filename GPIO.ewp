# IAR project GPIO.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S005K6 STM8S005K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\src; STM8S_StdPeriph_Driver\inc; User; Hal
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.hex
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8S_StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_tim4.c stm8s_uart2.c
  group User
    User/: main.c stm8s_it.c user_beep.c user_ctrl.c user_digitron.c user_gpio.c user_key.c user_time4.c user_uart.c
